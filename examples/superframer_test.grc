options:
  parameters:
    author: elms
    generate_options: qt_gui
    id: lich_dump
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: t1
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: m17_m17_lich_gen_0
  id: m17_m17_lich_gen
  parameters:
    dst: A
    nonce: ''
    src: B
    stream_type: '3'
  states: {}
- name: m17_superframe_combiner_0
  id: m17_superframe_combiner
  parameters: {}
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', m17_superframe_combiner_0, '2']
- [m17_m17_lich_gen_0, '0', m17_superframe_combiner_0, '0']
- [m17_m17_lich_gen_0, '0', m17_superframe_combiner_0, '1']
- [m17_superframe_combiner_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
