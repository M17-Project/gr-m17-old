options:
  parameters:
    author: elms
    generate_options: qt_gui
    id: vco_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delta_f
  id: variable
  parameters:
    value: '800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '64'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '38'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '3'
    samp_rate: samp_rate
    sensitivity: 2*3.14*delta_f
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,-3,-1,1,3]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Warning: May be wrong'
  states: {}
- name: note_1
  id: note
  parameters:
    note: Untested at the moment
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: mod
    label2: mod
    label3: bandlimited
    label4: bandlimited
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label2: rrc
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sps//1600
    interp: samp_rate//1600
    taps: 20*[1]
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '1'
    interp: '1'
    ntaps: '127'
    samp_rate: samp_rate
    sym_rate: sps
    type: interp_fir_filter_fff
  states: {}

connections:
- [blocks_char_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_map_bb_0, '0']
- [blocks_vco_c_0, '0', blocks_delay_1, '0']
- [blocks_vco_c_0, '0', low_pass_filter_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', blocks_delay_0_0, '0']
- [rational_resampler_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_vco_c_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
