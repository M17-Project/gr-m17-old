options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: viterbi_cc_decode
    output_language: python
    title: Use Viterbi to decode arbitrary CC
  states: {}

blocks:
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: fsm
  id: variable
  parameters:
    value: trellis.fsm("examples/m17.fsm")
  states: {}
- name: k
  id: variable
  parameters:
    value: '5'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[79, 109]'
  states: {state: disabled}
- name: polys
  id: variable
  parameters:
    value: '[25,23]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (10*frame_size//15)*[1, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_cc
    puncpat: puncpat
    threadtype: ordinary
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '60'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Generated using cc_helper.py
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    ctrlpanel: 'True'
    label1: Original Data
    label2: Decoded
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Dummy Code
    marker1: '0'
    size: '2048'
    srate: samp_rate*2
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: fsm.I()
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: '[-1, -1, -1, 1, 1, -1, 1, 1]'
    type: f
  states: {}
- name: trellis_viterbi_x_0_0
  id: trellis_viterbi_x
  parameters:
    block_size: '1024'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', trellis_metrics_x_0, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_1, '0']
- [fec_extended_encoder_0, '0', blocks_char_to_float_1_0_0, '0']
- [fec_extended_encoder_0, '0', digital_map_bb_0, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0_0, '0']
- [trellis_viterbi_x_0_0, '0', blocks_char_to_float_1_0, '0']

metadata:
  file_format: 1
