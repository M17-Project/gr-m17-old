options:
  parameters:
    author: elms
    generate_options: qt_gui
    id: m17_forward
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: m17_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: 18*8
    k: '5'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[25,23]'
    rate: '2'
    state_start: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: temp
    type: byte
    vlen: '48'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 48//8
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '34'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0,1,2,3,4,5,6,7,8,9,0,1,2,3,4,5]'
    vlen: 128//8
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '20'
    type: byte
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: m17_cc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: m17_add_crc_0
  id: m17_add_crc
  parameters:
    vlen: '18'
  states: {}
- name: m17_add_fn_0
  id: m17_add_fn
  parameters:
    fn_init: ''
  states: {}
- name: m17_add_sync_0
  id: m17_add_sync
  parameters: {}
  states: {}
- name: m17_golay_enc_0
  id: m17_golay_enc
  parameters:
    unpacked: 'False'
    vlen: 48//8
  states: {}
- name: m17_m17_lich_gen_0
  id: m17_m17_lich_gen
  parameters:
    dst: ABCDEFG
    nonce: ''
    src: HIJKLMN
    stream_type: '4'
  states: {}
- name: m17_vector_concat_0
  id: m17_vector_concat
  parameters:
    input_vlens: '[12, 272//8]'
    num_inputs: '2'
    type: byte
    verbose: 'False'
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: '46'
    syms_per_block: '1'
    table: '[0,1,2,3,4,5,6,7,8,9,0,1,2,3,4,5,6,7,8,9,0,1,2,3,4,5,6,7,8,9,0,1,2,3,4,5,6,7,8,9,0,1,2,3,4,5]'
    type: byte
    vlen: '46'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', m17_golay_enc_0, '0']
- [blocks_stream_to_vector_1, '0', m17_vector_concat_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_vector_source_x_0, '0', m17_add_fn_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [m17_add_crc_0, '0', blocks_vector_to_stream_0, '0']
- [m17_add_fn_0, '0', m17_add_crc_0, '0']
- [m17_add_sync_0, '0', blocks_file_sink_0, '0']
- [m17_golay_enc_0, '0', m17_vector_concat_0, '0']
- [m17_m17_lich_gen_0, '0', blocks_stream_to_vector_0, '0']
- [m17_vector_concat_0, '0', trellis_permutation_0, '0']
- [trellis_permutation_0, '0', m17_add_sync_0, '0']

metadata:
  file_format: 1
