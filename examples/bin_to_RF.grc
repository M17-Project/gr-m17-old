options:
  parameters:
    author: Woj SP5WWP
    generate_options: qt_gui
    id: bin_to_RF
    output_language: python
    title: M17 symbols to RF
  states: {}

blocks:
- name: f_offs
  id: variable_qtgui_range
  parameters:
    label: Offset (Hz)
    rangeType: int
    start: '-2000'
    step: '10'
    stop: '2000'
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '16'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*3.1415926535*800.0)/(symbol_rate*sps)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.dev
    type: short
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\SP5WWP\Desktop\GRC\sample_n2xdd_stream.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '7168.0'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[1,3,-1,-3]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    bandwidth: symbol_rate*sps*interp
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 435000000+f_offs
    samplerate: symbol_rate*sps*interp
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: interp
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: sps
    gain: sps
    interp: sps
    ntaps: 23*sps+1
    samp_rate: symbol_rate*sps
    sym_rate: symbol_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
