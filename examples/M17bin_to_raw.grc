options:
  parameters:
    author: SP5WWP
    generate_options: qt_gui
    id: M17bin_to_raw
    output_language: python
    title: M17 RRC baseband filter
  states: {}

blocks:
- name: rrc_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: baseband.raw
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: baseband.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 32767.0/5.0
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: baseband.wav
    format: FORMAT_WAV
    samp_rate: samp_rate*samp_per_sym
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: samp_per_sym
    interp: samp_per_sym
    ntaps: rrc_len*samp_per_sym+1
    samp_rate: samp_per_sym
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_short_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
